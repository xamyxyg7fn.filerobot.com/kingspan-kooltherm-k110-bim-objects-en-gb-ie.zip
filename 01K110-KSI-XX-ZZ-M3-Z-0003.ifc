Properties of the parts of a building model (IFC4X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: ef5cbcc7-b819-4b04-ad0d-7cac1267538f, NumberOfSaves: 9], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Internal]
File name: 01K110-KSI-XX-ZZ-M3-Z-0003.ifc
Time: 2025-06-24T13:55:34+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Kingspan Kooltherm® K110

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K110; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K110; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_BuildingStoreyCommon - Reference: Circle Head - Project Datum
Pset_SpaceCommon - IsExternal: no; Reference: Circle Head - Project Datum
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcBuildingElementProxy: Generic Models : Model Text : 600mm KI_CenturyGothic (9)
In: Level 0
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: 600mm KI_CenturyGothic
Type - Text - Bold: no; Italic: no; Text Font: Century Gothic; Text Size: 600 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 600mm KI_CenturyGothic
Pset_EnvironmentalImpactIndicators - Reference: 600mm KI_CenturyGothic
Other - Family: Model Text; Family and Type: Model Text: 600mm KI_CenturyGothic; Type: 600mm KI_CenturyGothic; Type Id: 305799
Constraints - Work Plane: Level : Level 0
Dimensions - Depth: 150 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Generic Models : Model Text :...) | Text
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 65mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 70mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 75mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 80mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 85mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 90mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 100mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 110mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K110 - 120mm

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-100
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 100 mm
Type - Dimensions - Length: 2400mm; Thickness: 100mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Keynote: K40; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.100mm.BIM-1047.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-100mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-100; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.19 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 5.26316 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.19 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-100 100 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-100
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-100
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-100; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-100; Type Id: 307840
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.288 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-110
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 110 mm
Type - Dimensions - Length: 2400mm; Thickness: 110mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.110mm.BIM-1048.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-110mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-110; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.172727 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 5.78947 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.172727 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-110 110 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-110
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-110
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-110; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-110; Type Id: 307872
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.3168 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-120
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 120 mm
Type - Dimensions - Length: 2400mm; Thickness: 120mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.120mm.BIM-1049.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-120mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-120; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.158333 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 6.31579 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.158333 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-120 120 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-120
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-120
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-120; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-120; Type Id: 307904
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.3456 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-65
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 65 mm
Type - Dimensions - Length: 2400mm; Thickness: 65mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.65mm.BIM-1041.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-65mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-65; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Heat Transfer Coefficient (U): 0.292308 kg/K/s3; Roughness: 3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.42105 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.292308 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-65 65 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-65
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-65
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-65; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-65; Type Id: 307287
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.1872 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-70
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 70 mm
Type - Dimensions - Length: 2400mm; Thickness: 70mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.70mm.BIM-1042.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-70mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-70; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.271429 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.68421 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.271429 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-70 70 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-70
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-70
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-70; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-70; Type Id: 307680
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.2016 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-75
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 75 mm
Type - Dimensions - Length: 2400mm; Thickness: 75mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.75mm.BIM-1043.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-75mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-75; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.253333 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.94737 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.253333 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-75 75 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-75
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-75
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-75; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-75; Type Id: 307712
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.216 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-80
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 80 mm
Type - Dimensions - Length: 2400mm; Thickness: 80mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.80mm.BIM-1044.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-80mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-80; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.2375 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.21053 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.2375 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-80 80 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-80
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-80
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-80; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-80; Type Id: 307744
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.2304 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-85
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 85 mm
Type - Dimensions - Length: 2400mm; Thickness: 85mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.85mm.BIM-1045.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-85mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-85; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.223529 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.47368 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.223529 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-85 85 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-85
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-85
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-85; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-85; Type Id: 307776
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.2448 m3
Phasing - Phase Created: New Construction

# IfcCovering: Ceilings : Compound Ceiling : KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-90
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Ceilings; Family Name: Compound Ceiling
Type - Construction - Thickness: 90 mm
Type - Dimensions - Length: 2400mm; Thickness: 90mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for structural ceilings (soffits).; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k110-gb-and-ireland/kingspan-kooltherm-k110-brochure-en-gb-ie.pdf; Keynote: K40; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K110; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K110.90mm.BIM-1046.V3.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K110-90mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-90; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/; Version: 3
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.211111 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.73684 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.211111 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass B-s2, d0 (exposed foil side), C-s2,d0 (non-exposed tissue side).
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-90 90 mm
Pset_CoveringCommon - IsExternal: no; Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-90
Pset_EnvironmentalImpactIndicators - Reference: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-90
Other - Family: Compound Ceiling; Family and Type: Compound Ceiling: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-90; Type: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard-90; Type Id: 307808
Constraints - Height Offset From Level: 0 mm; Level: Level 0; Room Bounding: yes
Dimensions - Area: 2.88 m2; Perimeter: 7200 mm; Volume: 0.2592 m3
Phasing - Phase Created: New Construction

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-65
Identity - Class: Generic
Thermal - Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(4); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Density: 0 kg/m3; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; Permeability: 0 s/m; Reflectivity: 0; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-65mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Color: 8820953; Glow: no; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-65; Shininess: 64; Smoothness: 50; Transparency: 0

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-70
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(5); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-70mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-70; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-75
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(6); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-75mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-75; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-80
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(7); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-80mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-80; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-85
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(8); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-85mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-85; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-90
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(9); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-90mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-90; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-100
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(1); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-100mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-100; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-110
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(2); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-110mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-110; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-120
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K110-SoffitBoard(3); Description: Phenolic Insulation for structural ceilings (soffits).; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for structural ceilings (soffits).; Manufacturer: Kingspan Insulation Ltd; Model: K110-120mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/floor-insulation-boards/kooltherm-k110-soffit-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K110-SoffitBoard-120; Shininess: 64; Smoothness: 50
